FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE_guruplug = "guruplug"
KMACHINE_guruplug = "guruplug"
KBRANCH_guruplug = "standard/arm-versatile-926ejs"

SRC_URI += "file://kirkwood.cfg"
